Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T16:45:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 16:45:02 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{15DDFC1F-B27D-452E-A46C-E69956B4B2F8}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 16:45:01 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 16:45:02 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 16:45:02 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR179 - HTC, Panca BRAIES D:0PAAR179 - HTC:149517
In: 0 - Piano Terra
Type - Material: HTC
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca BRAIES D
Type - Dati identità - BIM Name: BRAIES D; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR179; Designer: BELLITALIA DESIGN; Family Name: BRAIES; Nome del tipo: 0PAAR179 - HTC; URL Eng: https://www.bellitalia.net/en/products/benches/braies-collection/; URL Ita: https://www.bellitalia.net/prodotti/panchine/braies-collection/
Type - Dimensioni - Dimensions: 2600 mm x 650 mm x h 430 mm x H 780 mm
Type - Generale - Descrizione Tecnica Famiglia: Panca mod. "BRAIES" dritta monolitica. È dotata di schienale. Motivo di design tra piano di seduta e schienale, utile a far defluire l'acqua.; Descrizione Tecnica per Codice: PANCA BRAIES D IN HTC COLORATO (ECCETTO HTC 2 - AZZURRO) LISCIO CASSERO VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "Bench mod. ""BRAIES"" straight monolithic. It has a backrest. Design motif between the seat surface and the backrest, useful for water drainage."; Technical Description for Article: BRAIES D BENCH IN HTC COLORED (EXCEPT UTC 2 - BLUE) SMOOTH FORMWORK ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: HTC; Materiale Secondario: HTC; MATERIALE SEDUTA: HTC; Primary Material: HTC; Secondary Material: HTC
Type - Meccanica - Weight ( kg): 1124 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR179 - HTC
Altro - Famiglia: Panca BRAIES D: 0PAAR179 - HTC; Famiglia e tipo: Panca BRAIES D: 0PAAR179 - HTC; ID tipo: Panca BRAIES D: 0PAAR179 - HTC; Tipo: Panca BRAIES D: 0PAAR179 - HTC
Dimensioni - Area: 4.54314 m2; Volume: 0.468403 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
